# Keil uVision project RobotCore.uvprojx, settings and files
target Target (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RobotCore +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,MPU9250,EMPL_TARGET_STM32F4,EMPL
  c include: .\RVMDK\BSP;.\RVMDK\User;.\RVMDK\STM32F10x_StdPeriph_Driver;.\RVMDK\eMPL;.\RVMDK\CMSIS\CM3\CoreSupport;.\RVMDK\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\RVMDK\STM32F10x_StdPeriph_Driver\inc;.\RVMDK\DMP\driver\eMPL;.\RVMDK\DMP\driver\include;.\RVMDK\DMP\driver\stm32L;.\RVMDK\DMP\eMPL-hal;.\RVMDK\DMP\mllite;.\RVMDK\DMP\mpl
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./RVMDK/User/: main.c stm32f10x_it.c ahrs.c readme.txt
  group BSP
    ./RVMDK/BSP/: timer.c delay.c led.c usart.c encoder.c motor.c i2c.c mpu9250.c sys.c ps2.c servo.c w25q64.c adc.c
  group CMSIS
    ./RVMDK/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./RVMDK/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./RVMDK/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./RVMDK/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DMP
    ./RVMDK/DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./RVMDK/DMP/driver/stm32L/: log_stm32.c
    ./RVMDK/DMP/eMPL-hal/: eMPL_outputs.c
    ./RVMDK/DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./RVMDK/DMP/mpl/: libmpllib.lib
